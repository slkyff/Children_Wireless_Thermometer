# Keil uVision project sc_wt_bootloader.uvproj, settings and files
target sc_wt_bootloader_relese (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: sc_wt_bootloader +hex
  c flags: Optim=4
  c define: NRF51,DEBUG_NRF_USER, BOOTLOADER_BANKED BLE_STACK_SUPPORT_REQD,BOARD_NRF6310
  c misc: --c99
  c include: ..\Lib\Include\app_common;..\Lib\Include\ble;..\Lib\Include\ble\ble_services;..\Lib\Include\boards;..\Lib\Include\bootloader_dfu;..\Lib\Include\bootloader_dfu\ble_transport;..\Lib\Include\s110;..\Usr\include;..\Lib\Include\sd_common;..\Lib\Include
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002000 size 0x2000
  group App
    ../Usr/: main.c
  group Service
    ../Lib/Source/ble/ble_services/: ble_dfu.c
  group Lib
    ../Lib/Source/app_common/: pstorage.c app_button.c app_gpiote.c app_scheduler.c app_timer.c app_trace.c crc16.c hci_mem_pool.c
    ../Lib/Source/sd_common/: softdevice_handler.c
    ../Lib/Source/simple_uart/: simple_uart.c
    ../Lib/Source/nrf_delay/: nrf_delay.c
  group Startup
    ../Usr/: arm_startup_nrf51.s
    ../Lib/Source/templates/: system_nrf51.c
  group Dfu
    ../Lib/Source/bootloader_dfu/: dfu_app_handler.c bootloader.c bootloader_settings_arm.c bootloader_util_arm.c dfu_dual_bank.c
  group BleTransfer
    ../Lib/Source/bootloader_dfu/: dfu_transport_ble.c
    ../Lib/Source/ble/: ble_conn_params.c ble_advdata.c
    ../Lib/Source/ble/ble_services/: ble_srv_common.c
