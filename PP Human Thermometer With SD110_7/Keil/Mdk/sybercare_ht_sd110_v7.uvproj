# Keil uVision project sybercare_ht_sd110_v7.uvproj, settings and files
target Sybercare_ht_relese (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: sybercare_ht_sd110_v7 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\Lib\Include;..\Lib\Include\app_common;..\Lib\Include\ble\ble_services;..\Lib\Include\ble\device_manager;..\Lib\Include\boards;..\Lib\Include\s110;..\Lib\Include\sd_common;..\Lib\Include\sdk;..\Lib\Include\sdk_soc;..\Usr\Drv\inc;..\Usr\App\inc;..\Lib\Include\ble;..\Lib\Include\bootloader_dfu\ble_transport;..\Lib\Include\bootloader_dfu
  library: MicroLIB
  memory RVCT4: ROM 0x16000 size 0x26000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group App
    ../Usr/App/src/: main.c user_app_evt.c
  group Drv
    ../Usr/Drv/src/: user_drv_led_blink.c user_drv_pwr_ctrl.c user_drv_ad7171op.c user_drv_clock.c user_drv_console.c user_drv_bt_comm.c user_drv_self_def_service.c user_drv_bt_temp_gluing.c user_drv_offline_storage.c
  group Lib
    ../Lib/Source/ble/: ble_advdata.c ble_sensorsim.c ble_conn_params.c ble_error_log.c ble_debug_assert_handler.c
    ../Lib/Source/ble/ble_services/: ble_srv_common.c
    ../Lib/Source/app_common/: app_timer.c app_trace.c pstorage.c crc16.c app_button.c app_gpiote.c app_scheduler.c app_uart_fifo.c app_fifo.c
    ../Lib/Source/sd_common/: softdevice_handler.c
    ../Lib/Source/simple_uart/: simple_uart.c
    ../Lib/Source/ble/device_manager/: device_manager_peripheral.c
    ../Lib/Source/spi_master/: spi_master.c
    ../Lib/Source/nrf_delay/: nrf_delay.c
  group Sevices
    ../Lib/Source/ble/ble_services/: ble_dfu.c ble_hts.c ble_bas.c ble_dis.c
  group Startup
    ../Lib/Startup/: system_nrf51.c arm_startup_nrf51.s
  group Dfu
    ../Lib/Source/bootloader_dfu/: bootloader_util_arm.c dfu_app_handler.c
target Sybercare_ht_debug (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: sybercare_ht_sd110_v7
  c flags: Optim=1 OneElfS=1
  c misc: --c99
  c include: ..\Lib\Include;..\Lib\Include\app_common;..\Lib\Include\ble\ble_services;..\Lib\Include\ble\device_manager;..\Lib\Include\boards;..\Lib\Include\s110;..\Lib\Include\sd_common;..\Lib\Include\sdk;..\Lib\Include\sdk_soc;..\Usr\Drv\inc;..\Usr\App\inc;..\Lib\Include\ble
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
